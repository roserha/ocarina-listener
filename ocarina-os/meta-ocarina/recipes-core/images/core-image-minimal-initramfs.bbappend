PACKAGE_INSTALL:append = " initramfs-module-ocarina-splash"